KERNEL_GIT_URI = "git://github.com/jonathanherbst/ti-linux.git"
KERNEL_GIT_PROTOCOL = "https"
BRANCH = "ti-linux-j1939-4.19.y"
SRCREV = "b5d446ea3735554cfda0bb11712fa0f72aabc194"